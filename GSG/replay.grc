options:
  parameters:
    generate_options: qt_gui
    id: replay
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: push_freq
  id: variable
  parameters:
    comment: |-
      make sure this matches
      the capture freq and sample rate!
    value: 4339e5
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      make sure this matches
      the capture freq and sample rate!
    value: 2e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\127CPB\Documents\HackRF_SDR_Dev_Files\car_remote_sink
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: 100e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: push_freq
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', osmosdr_sink_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
