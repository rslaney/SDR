options:
  parameters:
    generate_options: qt_gui
    id: capture
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: capture_freq
  id: variable
  parameters:
    comment: |-
      make sure this matches
      the capture freq and sample rate!
    value: 4339e5
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\127CPB\Documents\HackRF_SDR_Dev_Files\car_remote_sink
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: capture_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: capture_freq
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
