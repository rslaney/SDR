options:
  parameters:
    generate_options: qt_gui
    id: Spectrum_Analyzer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BB_Gain_Slider
  id: variable_qtgui_range
  parameters:
    comment: |-
      0 to 62 in 2 dB steps
      https://hackrf.readthedocs.io/
      en/latest/setting_gain.html
    start: '0'
    step: '2'
    stop: '62'
    value: '0'
  states: {}
- name: IF_Gain_Slider
  id: variable_qtgui_range
  parameters:
    comment: |-
      Adjustable in 8 dB increments
      https://hackrf.readthedocs.io/
      en/latest/setting_gain.html
    start: '0'
    step: '8'
    stop: '40'
    value: '0'
  states: {}
- name: RF_Gain_Slider
  id: variable_qtgui_range
  parameters:
    comment: |-
      Toggle on or off
      https://hackrf.readthedocs.io/
      en/latest/setting_gain.html
    start: '0'
    step: '11'
    stop: '11'
    value: '0'
  states: {}
- name: frequency_slider
  id: variable_qtgui_range
  parameters:
    comment: |-
      Dynamically tune frequency
      within HackRF range
      (100e3 - 700e7)
    start: 100e3
    step: 100e3
    stop: 700e7
    value: 88e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Frequency Sink gives the Spectrum Plot
      Waterfall Sink gives the visual history
      Sliders allow adjusting noise floor on the fly
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    bw0: '100'
    freq0: frequency_slider
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: frequency_slider
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Use this to decmate sample rate
      (create zoom effect)
    decim: '1'
    interp: '1'
    type: ccf
  states: {}

connections:
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
